# Keil uVision project IDC_project.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: IDC_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\HARDWARE\REMOTE;..\HARDWARE\ACTUATOR;..\HARDWARE\VESC_CAN;..\HARDWARE\LINE_FOLLOW;..\HARDWARE\IMU_TEST
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ../CORE/: startup_stm32f40_41xxx.s
    ../USER/: system_stm32f4xx.c stm32f4xx_it.c main.c
    ../HARDWARE/REMOTE/: remote.c
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_can.c stm32f4xx_adc.c
    ../HARDWARE/ACTUATOR/: actuator.c
    ../HARDWARE/VESC_CAN/: vesc_can.c
    ../HARDWARE/LINE_FOLLOW/: line_follow.c
    ../HARDWARE/IMU_TEST/: imu_test.c
